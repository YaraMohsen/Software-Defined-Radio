options:
  parameters:
    author: Yara Mohsen
    generate_options: qt_gui
    id: day5_qpsk
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: freq
    orient: Qt.Horizontal
    start: '-100e-3'
    step: '1e-3'
    stop: '100'
    value: '0'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: gain
    orient: Qt.Horizontal
    start: '0'
    step: '1e-3'
    stop: '100e-3'
    value: '10e-3'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: noise
    orient: Qt.Horizontal
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '100e-6'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    label: phase_bw
    orient: Qt.Horizontal
    start: '0'
    step: '10e-3'
    stop: '1'
    value: '62.8e-3'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts,nfilts,1.0/float(sps),excess_bw,45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0,0.25-0.25j,0.5+0.1j,-0.3+0.2j]'
  states: {}
- name: time
  id: variable_qtgui_range
  parameters:
    label: time
    orient: Qt.Horizontal
    start: '999e-3'
    step: '1e-6'
    stop: '1.001'
    value: '1'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: time
    freq_offset: freq
    noise_voltage: noise
    seed: '0'
    taps: taps
  states: {}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1'
    mu: gain
    num_taps: '11'
    sps: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '4'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: '62.8e-3'
    max_dev: '1.5'
    osps: '2'
    sps: '4.004'
    taps: rrc_taps
    type: ccf
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_cma_equalizer_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_cma_equalizer_cc_0, '0']

metadata:
  file_format: 1
